# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\Project;..\STM32F10x_FWLib\inc;..\HARDWAVE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\UCOSIII\uC-CPU;..\UCOSIII\uC-LIB;..\UCOSIII\uCOS-III;..\UCOSIII\UCOS_BSP;..\UCOSIII\UCOS_CONFIG;..\UCOSIII\uCOS-III\Source;..\UCOSIII\uC-CPU\ARM-Cortex-M3\RealView;..\UCOSIII\uC-LIB\Ports\ARM-Cortex-M3\RealView;..\UCOSIII\uCOS-III\Ports\ARM-Cortex-M3\Generic\RealView;..\HARDWAVE\ADC;..\HARDWAVE\CAN;..\HARDWAVE\TIMER;..\HARDWAVE\DEBUG;..\HARDWAVE\DRIVER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Project
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_cl.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWAVE/LED/: led.c
    ../HARDWAVE/ADC/: adc.c
    ../HARDWAVE/CAN/: can.c
    ../HARDWAVE/TIMER/: timer.c
    ../HARDWAVE/DEBUG/: debug.c
    ../HARDWAVE/DRIVER/: driver.c
    ./: pwm.c driver2.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group UCOSIII-BSP
    ../UCOSIII/UCOS_BSP/: bsp.c
  group UCOSIII-CPU
    ../UCOSIII/uC-CPU/: cpu_core.c
    ../UCOSIII/uC-CPU/ARM-Cortex-M3/RealView/: cpu_a.asm cpu_c.c
  group UCOSIII-LIB
    ../UCOSIII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../UCOSIII/uC-LIB/Ports/ARM-Cortex-M3/RealView/: lib_mem_a.asm
  group UCOSIII-CORE
    ../UCOSIII/uCOS-III/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group UCOSIII-PORT
    ../UCOSIII/uCOS-III/Ports/ARM-Cortex-M3/Generic/RealView/: os_cpu.h os_cpu_a.s os_cpu_c.c
  group UCOSIII-CONFIG
    ../UCOSIII/UCOS_CONFIG/: app_cfg.h cpu_cfg.h includes.h lib_cfg.h os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
